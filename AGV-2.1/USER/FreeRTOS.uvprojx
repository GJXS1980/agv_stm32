# Keil uVision project FreeRTOS.uvprojx, settings and files
target ARV-FreeRTOS (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\TIMER;..\HARDWARE\BEEP;..\HARDWARE\ADC;..\HARDWARE\GY_US42\IIC;..\HARDWARE\GY_US42;..\HARDWARE\HDT11;..\HARDWARE\IWDG;..\HARDWARE\USART2;..\HARDWARE\IMU;..\HARDWARE\GPIO;..\HARDWARE\GY_US42\IIC;..\HARDWARE\Infrared;..\HARDWARE\TIM;..\HARDWARE\URF02;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\MPU9250\IIC;..\HARDWARE\SCOP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/GY_US42/IIC/: IIC.c
    ../HARDWARE/HDT11/: dht11.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/TIM/: TIM_6_7.c tim9.c
    ../HARDWARE/URF02/: urf02.c
    ../HARDWARE/MPU9250/IIC/: myiic.c
    ../HARDWARE/MPU9250/: mpu9250.c
    ../HARDWARE/Infrared/: infrared.c
    ../HARDWARE/SCOP/: outputdata.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group MPL
    ../HARDWARE/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9250/MPL/mpl/: libmpllib.lib
